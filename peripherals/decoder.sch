** sch_path: peripherals/decoder.sch
**.subckt decoder I2 I1 I0 Y7 Y6 Y5 Y4 Y3 Y2 Y1 Y0 VCC VSS EN
*.iopin I2
*.iopin I1
*.iopin I0
*.iopin Y7
*.iopin Y6
*.iopin Y5
*.iopin Y4
*.iopin Y3
*.iopin Y2
*.iopin Y1
*.iopin Y0
*.iopin VCC
*.iopin VSS
*.iopin EN
x3 I2_bar I2 inv
x4 I1_bar I1 inv
x5 I0_bar I0 inv
x1 VCC VSS I0 I1 I2 EN Y7 and4
x2 VCC VSS I0_bar I1 I2 EN Y6 and4
x6 VCC VSS I0 I1_bar I2 EN Y5 and4
x7 VCC VSS I0_bar I1_bar I2 EN Y4 and4
x8 VCC VSS I0 I1 I2_bar EN Y3 and4
x9 VCC VSS I0_bar I1 I2_bar EN Y2 and4
x10 VCC VSS I0 I1_bar I2_bar EN Y1 and4
x11 VCC VSS I0_bar I1_bar I2_bar EN Y0 and4
**.ends

* expanding   symbol:  inv.sym # of pins=2
** sym_path: inv.sym
** sch_path: inv.sch
.subckt inv OUT[expr(@width - 1):0] IN[expr(@width - 1):0]
*.ipin IN[@width - 1:0]
*.opin OUT[@width - 1:0]
M1[@width - 1:0] OUT[@width - 1:0] IN[@width - 1:0] GND GND cmosn w=2u l=1u m=1
M2[@width -1:0] OUT[@width - 1:0] IN[@width - 1:0] VDD VDD cmosp w=5u l=1u m=1
.ends


* expanding   symbol:  logic gates/and4.sym # of pins=7
** sym_path: logic gates/and4.sym
** sch_path: logic gates/and4.sch
.subckt and4 VCC VSS A B C D Y
*.iopin VSS
*.iopin Y
*.iopin A
*.iopin B
*.iopin C
*.iopin VCC
*.iopin D
x1 VCC Y net1 net2 VSS nor
x2 VCC net1 A B VSS nand
x3 VCC net2 C D VSS nand
.ends


* expanding   symbol:  logic gates/nor.sym # of pins=5
** sym_path: logic gates/nor.sym
** sch_path: logic gates/nor.sch
.subckt nor VCC Y A B VSS
*.iopin VCC
*.iopin VSS
*.iopin Y
*.iopin A
*.iopin B
XM2 Y B VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XM11 Y B net1 VCC sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM1 Y A VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XM3 net1 A VCC VCC sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  logic gates/nand.sym # of pins=5
** sym_path: logic gates/nand.sym
** sch_path: logic gates/nand.sch
.subckt nand VCC Y A B VSS
*.iopin VCC
*.iopin VSS
*.iopin Y
*.iopin A
*.iopin B
XM2 net1 B VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XM11 Y A VCC VCC sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM1 Y A net1 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XM3 Y B VCC VCC sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends

.GLOBAL VDD
.GLOBAL GND
.end
